# Keil uVision project CH375_F103Host转发.uvprojx, settings and files
target STM32F103RB (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103VB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: CH375_F103Host转发 +hex
  c flags: OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: ..\User;..\Libraries\CMSIS\CM3\CoreSupport;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\Public;..\Driver;..\CmBacktrace\cm_backtrace;..\App;..\F103_CustomHID\CustomHID\inc;..\F103_CustomHID\STM32_USB-FS-Device_Driver\inc;..\Public\inc;..\Driver\inc;..\Driver\CH375;..\Public\TM_library;..\Public\multi_timer
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ../User/: main.c stm32f10x_it.c system_stm32f10x.c
  group CMSIS
    ../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_cl.s startup_stm32f10x_hd.s startup_stm32f10x_hd_vl.s startup_stm32f10x_ld.s startup_stm32f10x_ld_vl.s startup_stm32f10x_md.s startup_stm32f10x_md_vl.s startup_stm32f10x_xl.s
  group StdPeiph_Driver
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_exti.c stm32f10x_adc.c stm32f10x_dma.c
  group cm_backtrace
    ../CmBacktrace/cm_backtrace/: cmb_fault.S cmb_def.h cm_backtrace.c cm_backtrace.h cmb_cfg.h
  group TM_Library
    ../Public/TM_library/: tm_stm32_gpio.c tm_stm32_spi.c tm_stm32_DMA.c TM_que.c tm_string.c tm_dev_spi.c tm_fm25cl64.c
    ../Public/: tm_library.h
  group Public
    ../Public/: Public.h
    ../Public/multi_timer/: multi_timer.c
    ../Public/src/: debug.c delay.c Exti.c PWM.c queue.c SPI_dri.c sys.c Timer.c usart.c des.c
  group Driver
    ../Driver/: driver.h
    ../Public/SalveSPI/: SalveSPI.c
    ../Public/MasterSPI/: MasterSPI.c
    ../Driver/src/: io_intput.c segled.c SPI_communicate.c
    ../Driver/CH375_Host/src/: CH375.c CH375_Device.c CTRL_HID.C
  group App
    ../Driver/: notecat.c printer.c
    ../Driver/src/: HID_Data.c
    ../App/: Key.c
  group Doc
    ../Doc/: 硬件文档.txt 开发文档.txt
  group USB-FS-Device_Driver
    ../F103_CustomHID/STM32_USB-FS-Device_Driver/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group HID_Config
    ../F103_CustomHID/CustomHID/src/: hw_config.c MyHID_Driver.c stm32_it.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c
  group CH375Host
    ../Driver/CH375/: HOST_SYS.C para.c CH375_App.c
